# Keil uVision project TheLastHope.uvproj, settings and files
target TheLastHope (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TheLastHope
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Principal
    ./: TheLastHope.c
  group Bibliotecas
    ./: tm4c123gh6pm.h startup.s LEDS_Y_PULSADORES.c LEDS_Y_PULSADORES.h PLL.c PLL.h SysTick.c SysTick.h UART.c UART.h ST7735.c ST7735.h DAC.c DAC.h
  group Librerias
    ./: MODO_JUEGO.c MODO_JUEGO.h mostrar_ocultar.c mostrar_ocultar.h MENU.c MENU.h
